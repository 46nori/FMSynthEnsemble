# Repository 46nori/FMSynthEnsemble

File README.md:

# FMSynthEnsemble

## 特徴

- FM音源シンセサイザ
  - YAMAHAのOPN系FM音源(YM2203/YM2608)を使用
- (ほぼ)GM準拠 USB MIDI音源
  - [MIDIインプリメンテーションチャート](./software/midism/docs/MIDI_ImplementationChart.md)
- CSMモードによる複合正弦波音声合成をサポート

YM2203(OPN), YM2806(OPNA)はモジュール基板となっており、コントローラーモジュールに最大4台まで混在接続が可能。システムコントローラにはRaspberryPi Picoを使用している。YM2608モジュールを4台を接続した場合、24マルチティンバー・24ポリフォニック+リズム6音の発音が可能なMIDI音源となる。

## CSM音声合成のデモ

- YouTubeビデオ  
YMOのソリッドステートサヴァイヴァーに収録されているテクノポリスの坂本龍一の音声を、複合正弦波音声分析で特徴量抽出し、YM2608のCSMモードで音声合成させている。  

## ソフトウェア

- [環境設定・ビルド方法](./software/midism/README.md)
- [ソフトウェア設計仕様書](./software/midism/docs/README.md)

## ハードウェア

- [ハードウェア設計仕様書](./hardware/README.md)
- [データシート他](./doc/datasheet/README.md)

||||
|---|---|---|
||||
||||
||||

## ライセンス

MIT License

## KiCad design hardware/ControlPanel/ControlPanel.kicad_pcb

File hardware/README.md:

# ハードウェア

## 構造

モジュール構造のハードウェアとなっている。
コントローラモジュールには4本のDockがあり、FM音源モジュールを接続する。YM2203とYM2608が混在可能。  
FM音源モジュールのアナログ出力は、ミキサー・アンプモジュールを接続する。  
コントロールパネルモジュールはFM音源モジュールのI/Oポートに接続する。

### コントローラモジュール

電源容量や実装の制約上、Dock数は4つまでとしているが、回路的には7台までのFM音源モジュールを制御可能。PCBは製作していない。

システムコントローラーはRaspberryPi Pico2を使用しているが、パフォーマンスは若干落ちるがPicoも使用可能。

FM音源モジュールの制御に以下の19本のGPIOを使用している。

- /CS生成用3bit
- /RD, /WR
- A0, A1
- D0 - D8
- /IRQ (4bit)

FM音源LSIは5V系なので、Raspberry Pi Picoとの接続には[AE-LLCNV8-DIP20](https://akizukidenshi.com/catalog/g/g117062/)などで3.3V/5Vレベル変換が必要である。

アナログ回路の低ノイズ化を考慮して、秋月電子の超ローノイズ可変電圧キット[AE-TPS7A4700](https://akizukidenshi.com/catalog/g/g106194/)を5V出力で使用している。
消費電流は800mA程度を見込む必要があり、入出力電圧差は1V程度としなければならない。
6V/1.8Aの[AD-A60P180](https://akizukidenshi.com/catalog/g/g111997/)を推奨ACアダプタとする。

### FM音源モジュール：YM2203(OPN)

クロックは4MHz。FM音源1ch(モノラル), SSG音源1ch出力。I/O PORT用端子あり。
PCB製作済み。

### FM音源モジュール：YM2806(OPNA)

クロックは8MHz。FM音源2ch(ステレオ), SSG音源1ch出力。I/O PORT用端子あり。ADPCMには非対応。
PCB製作済み。

### ミキサー・アンプモジュール

4つ分のFM音源モジュール出力をオペアンプで加算し、ローパスフィルターを通した後、秋月電子のスピーカーアンプキット[AE-PAM8403-AMP](https://akizukidenshi.com/catalog/g/g115698/)に入力している。PCBは製作していない。

電源は[AE-TPS7A4700](https://akizukidenshi.com/catalog/g/g106194/)の5V出力に接続する。FM音源モジュール1つにつきFM音源出力2ch(YM2203は1ch)とSSG音源1chの合計3chの出力があるので、テストプログラムで440Hzの音を出しながら、3個のボリュームでそれぞれのレベルを調整する。

### コントロールパネルモジュール

FM音源モジュールのPORT-A/Bに接続することで、MIDIチャンネルのON/OFF、MIDIリセットができるようになる。LEDはMIDIチャンネルごとのKeyOn状態、またはON/OFF状態を表示する。

ポートのビット数や入出力方向に制限があるため、マトリックス回路構成にしている。PCB製作済み。

(YM2608(OPNA)モジュール基板のPort-A/Bまわりの回路図にバグがある。MSB/LSBが反転しているため、config.hでワークアラウンドを有効にする必要がある。)

## KiCad

回路図およびPCBの作成には[KiCad8](https://www.kicad.org/)を使用した。

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D17: CH1; LED_Rectangular_W5.0mm_H2.0mm
D18: CH2; LED_Rectangular_W5.0mm_H2.0mm
D19: CH3; LED_Rectangular_W5.0mm_H2.0mm
D20: CH4; LED_Rectangular_W5.0mm_H2.0mm
D21: CH5; LED_Rectangular_W5.0mm_H2.0mm
D22: CH6; LED_Rectangular_W5.0mm_H2.0mm
D23: CH7; LED_Rectangular_W5.0mm_H2.0mm
D24: CH8; LED_Rectangular_W5.0mm_H2.0mm
D25: CH9; LED_Rectangular_W5.0mm_H2.0mm
D26: CH10; LED_Rectangular_W5.0mm_H2.0mm
D27: CH11; LED_Rectangular_W5.0mm_H2.0mm
D28: CH12; LED_Rectangular_W5.0mm_H2.0mm
D29: CH13; LED_Rectangular_W5.0mm_H2.0mm
D30: CH14; LED_Rectangular_W5.0mm_H2.0mm
D31: CH15; LED_Rectangular_W5.0mm_H2.0mm
D32: CH16; LED_Rectangular_W5.0mm_H2.0mm
J1: F_GPIO; PinHeader_2x10_P2.54mm_Vertical
Q1, Q2, Q3, Q4: 2SA1015; TO-92_Inline
Q5, Q6, Q7, Q8: 2SC1815; TO-92_Inline
R1, R2, R3, R4: 200; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5, R6, R7, R8, R9, R10, R11, R12: 4.7K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RN1: 10K; R_Array_SIP9
SW1: CH1; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW2: CH2; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW3: CH3; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW4: CH4; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW5: CH5; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW6: CH6; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW7: CH7; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW8: CH8; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW9: CH9; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW10: CH10; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW11: CH11; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW12: CH12; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW13: CH13; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW14: CH14; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW15: CH15; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW16: CH16; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
SW17: MIDI RESET; SW_PUSH-12mm
SW18: MONITOR; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm

Connections:
GND: J1.1, J1.2, Q5.1 (E), Q6.1 (E), Q7.1 (E), Q8.1 (E), SW17.1, SW18.1 (A); also elsewhere on the board
GPIOA0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), J1.5, R5.1
GPIOA1: D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), J1.7, R8.1
GPIOA2: D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), J1.9, R7.1
GPIOA3: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), J1.11, R6.1
GPIOA4: J1.13, R9.1
GPIOA5: J1.15, R10.1
GPIOA6: J1.17, R11.1
GPIOA7: J1.19, R12.1
GPIOB0: J1.6, RN1.9 (R8), SW1.1 (A), SW5.1 (A), SW9.1 (A), SW13.1 (A)
GPIOB1: J1.8, RN1.8 (R7), SW2.1 (A), SW6.1 (A), SW10.1 (A), SW14.1 (A)
GPIOB2: J1.10, RN1.7 (R6), SW3.1 (A), SW7.1 (A), SW11.1 (A), SW15.1 (A)
GPIOB3: J1.12, RN1.6 (R5), SW4.1 (A), SW8.1 (A), SW12.1 (A), SW16.1 (A)
unnamed: D1.2 (A), SW1.2 (B)
unnamed: D2.2 (A), SW2.2 (B)
unnamed: D3.2 (A), SW3.2 (B)
unnamed: D4.2 (A), SW4.2 (B)
unnamed: D5.2 (A), SW5.2 (B)
unnamed: D6.2 (A), SW6.2 (B)
unnamed: D7.2 (A), SW7.2 (B)
unnamed: D8.2 (A), SW8.2 (B)
unnamed: D9.2 (A), SW9.2 (B)
unnamed: D10.2 (A), SW10.2 (B)
unnamed: D11.2 (A), SW11.2 (B)
unnamed: D12.2 (A), SW12.2 (B)
unnamed: D13.2 (A), SW13.2 (B)
unnamed: D14.2 (A), SW14.2 (B)
unnamed: D15.2 (A), SW15.2 (B)
unnamed: D16.2 (A), SW16.2 (B)
unnamed: D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), R1.1
unnamed: D17.1 (K), D21.1 (K), D25.1 (K), D29.1 (K), Q5.2 (C)
unnamed: D18.1 (K), D22.1 (K), D26.1 (K), D30.1 (K), Q6.2 (C)
unnamed: D19.1 (K), D23.1 (K), D27.1 (K), D31.1 (K), Q7.2 (C)
unnamed: D20.1 (K), D24.1 (K), D28.1 (K), D32.1 (K), Q8.2 (C)
unnamed: D21.2 (A), D22.2 (A), D23.2 (A), D24.2 (A), R2.1
unnamed: D25.2 (A), D26.2 (A), D27.2 (A), D28.2 (A), R3.1
unnamed: D29.2 (A), D30.2 (A), D31.2 (A), D32.2 (A), R4.1
unnamed: Q1.3 (B), R5.2
unnamed: Q1.2 (C), R1.2
unnamed: Q2.3 (B), R8.2
unnamed: Q2.2 (C), R2.2
unnamed: Q3.3 (B), R7.2
unnamed: Q3.2 (C), R3.2
unnamed: Q4.3 (B), R6.2
unnamed: Q4.2 (C), R4.2
unnamed: Q5.3 (B), R9.2
unnamed: Q6.3 (B), R10.2
unnamed: Q7.3 (B), R11.2
unnamed: Q8.3 (B), R12.2
unnamed: J1.20, RN1.2 (R1), SW17.2
unnamed: J1.18, RN1.3 (R2), SW18.2 (B)
unnamed 51: J1.16, RN1.4 (R3); also elsewhere on the board
unnamed 52: J1.14, RN1.5 (R4); also elsewhere on the board
VCC: J1.3, J1.4, Q1.1 (E), Q2.1 (E), Q3.1 (E), Q4.1 (E), RN1.1 (common); also elsewhere on the board

Notes on the sheet:
1N4148について GPIOBは10Kでプルアップしているので順方向電流If=0.5mA このときの順方向電圧降下Vf=0.6V これは0.8Vよりも低いのでTTLのLレベルとして認識可能。 問題ある場合はVfの低いショットキーダイオードを使用する。
MIDI CH ON/OFF Indicator
MIDI CH ON/OFF Switch

Board: 2 copper layers, 100.0 x 75.0 mm, 115 parts (1 on the bottom side), 54 nets.

Other parts of the board:
REF1, REF2, REF3, REF4: MountingHole_3.2mm_M3_ISO7380_Pad
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20, TP21, TP22, TP23, TP24, TP25, TP26, TP27, TP28, TP29, TP30, TP31, TP32, TP33, TP34, TP35, TP36, TP37, TP38, TP39: TestPoint_THTPad_D1.5mm_Drill0.7mm

Their connections:
GND: TP20.1, TP29.1; also elsewhere on the board
unnamed 51: TP38.1; also elsewhere on the board
unnamed 52: TP39.1; also elsewhere on the board
VCC: TP1.1, TP7.1; also elsewhere on the board

## KiCad design hardware/Controller/SystemController.kicad_pcb

Board: 4 copper layers, 180.0 x 81.3 mm, 67 parts (0 on the bottom side), 77 nets.

Parts:
C101, C102, C104, C105, C106, C107, C108, C109, C110, C201, C202, C207: 0.1u; C_Axial_L3.8mm_D2.6mm_P7.50mm_Horizontal
C103: 0.33u; C_Axial_L3.8mm_D2.6mm_P7.50mm_Horizontal
C203, C204, C206: 10u; CP_Radial_D6.3mm_P2.50mm
C205: 1000p; C_Axial_L3.8mm_D2.6mm_P7.50mm_Horizontal
D101: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
J101: UART; PinHeader_1x04_P2.54mm_Vertical
J102: MIDI IN; DIN-5P-Socket
J103: MIDI IN; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J104: DC 7-12V / 1A; BarrelJack_Horizontal
J105: Power SW; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J106: FMB1; PinSocket_2x11_P2.54mm_Horizontal
J107: FMB0; PinSocket_2x11_P2.54mm_Horizontal
J108: FMB3; PinSocket_2x11_P2.54mm_Horizontal
J109: FMB2; PinSocket_2x11_P2.54mm_Horizontal
J110: AnalogIn_0; PinSocket_1x04_P2.54mm_Horizontal
J111: AnalogIn_1; PinSocket_1x04_P2.54mm_Horizontal
J112: AnalogIn_2; PinSocket_1x04_P2.54mm_Horizontal
J113: AnalogIn_3; PinSocket_1x04_P2.54mm_Horizontal
J201: Audio Out; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J202: AudioJack3; Jack_3.5mm_Ledino_KB3SPRS_Horizontal
JP101: +5V; PinHeader_2x01_P2.54mm_Vertical
JP102: Bridge
OC101: TLP2361; SO-6_4.4x3.6mm_P1.27mm
POWER101: LED; LED_D4.0mm
R101: 390; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R102, R103, R104, R106: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P2.54mm_Vertical
R105: 1K; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R201, R202, R203, R204, R205: 10K; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
REF1, REF2, REF3, REF4: MountingHole_3.2mm_M3_ISO7380_Pad
RV201, RV202: 1K; Potentiometer_Bourns_3339P_Vertical
SW101: Power SW; 2MD1-T1-B4-VS2-Q-E
SW102: RESET; SW_PUSH_6mm_H7.3mm
U101: Pico; RPi_Pico_SMD_TH
U102, U103: AE-LLCNV8-DIP20; DIP-20_W7.62mm_Socket
U104: NJM7805; TO-220-3_Vertical
U105, U107: 74HC00; DIP-14_W7.62mm_Socket
U106: 74HC74; DIP-14_W7.62mm_Socket
U201, U202: NJM4580; DIP-8_W7.62mm_Socket
U203: MCP4018; SOT-363_SC-70-6
X101: 16MHz; Oscillator_DIP-8

Connections:
3.3V: C101.1, C102.1, C106.1, C207.1, OC101.6 (VCC), R102.1, R103.1, R104.1, R106.1, U101.36 (3V3), U102.1 (VCCA), U103.1 (VCCA), U203.1 (VDD)
4MHz: J106.8, J107.8, J108.8, J109.8, U106.9 (Q)
8MHz: J106.6, J107.6, J108.6, J109.6, U106.5 (Q), U106.11 (C)
/A0: U101.9 (GPIO6), U102.8 (A6)
/A1: U101.10 (GPIO7), U102.9 (A7)
/Mixer/FM: J110.3, J111.3, J112.3, J113.3, R201.1, U201.2 (-)
/Mixer/REFV: J110.2, J111.2, U201.3 (+), U201.5 (+), U202.3 (+)
/Mixer/SSG: J110.4, J111.4, J112.4, J113.4, R202.1, U201.6 (-)
/RX: J101.3, U101.7 (GPIO5)
/TX: J101.4, U101.6 (GPIO4)
//RD: U101.4 (GPIO2), U102.6 (A4)
//WR: U101.5 (GPIO3), U102.7 (A5)
D0: U101.11 (GPIO8), U103.2 (A0)
D1: U101.12 (GPIO9), U103.3 (A1)
D2: U101.14 (GPIO10), U103.4 (A2)
D3: U101.15 (GPIO11), U103.5 (A3)
D4: U101.16 (GPIO12), U103.6 (A4)
D5: U101.17 (GPIO13), U103.7 (A5)
D6: U101.19 (GPIO14), U103.8 (A6)
D7: U101.20 (GPIO15), U103.9 (A7)
F_D0: J106.7, J107.7, J108.7, J109.7, U103.19 (B0)
F_D1: J106.9, J107.9, J108.9, J109.9, U103.18 (B1)
F_D2: J106.11, J107.11, J108.11, J109.11, U103.17 (B2)
F_D3: J106.13, J107.13, J108.13, J109.13, U103.16 (B3)
F_D4: J106.15, J107.15, J108.15, J109.15, U103.15 (B4)
F_D5: J106.17, J107.17, J108.17, J109.17, U103.14 (B5)
F_D6: J106.19, J107.19, J108.19, J109.19, U103.13 (B6)
F_D7: J106.21, J107.21, J108.21, J109.21, U103.12 (B7)
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, C109.2, C110.2, J101.2, J104.2 (Ext), J106.1, J106.2, J107.1, J107.2, J108.1, J108.2, J109.1, J109.2, JP102.1 (A), OC101.4 (GND), POWER101.1 (K), SW102.2, U101.3 (GND), U101.8 (GND), U101.13 (GND), U101.18 (GND), U101.23 (GND), U101.28 (GND), U101.38 (GND), U102.10 (GND), U102.11 (~OE), U103.10 (GND), U103.11 (~OE), U104.2 (GND), U105.7 (GND), U106.7 (GND), U107.7 (GND), X101.4 (GND)
GNDA: C201.2, C202.2, C207.2, J110.1, J111.1, J112.1, J113.1, J201.2, J202.S, JP102.2 (B), RV201.3, RV202.3, U201.4 (V-), U202.4 (V-), U202.5 (+), U202.6 (-), U203.2 (VSS)
I2C0_SCL: U101.27 (GPIO21), U203.3 (SCL)
I2C0_SDA: U101.26 (GPIO20), U203.4 (SDA)
unnamed: C203.1, RV201.2
unnamed: C203.2, R203.1
unnamed: C204.1, RV202.2
unnamed: C204.2, R204.1
unnamed: C205.2, C206.1, R205.2, U202.1
unnamed: D101.2 (A), J102.2, J103.2, OC101.3
unnamed: D101.1 (K), OC101.1, R101.1
unnamed: J101.1, JP101.1 (A)
unnamed: J102.4, J103.1, R101.2
unnamed: J104.1 (In), J105.1, SW101.2 (B), SW101.5 (B)
unnamed: POWER101.2 (A), R105.2
unnamed: R201.2, RV201.1, U201.1
unnamed: R202.2, RV202.1, U201.7
unnamed: OC101.5, U101.2 (GPIO1)
unnamed: U101.29 (GPIO22), U102.3 (A1)
unnamed: U101.31 (GPIO26_ADC0), U102.5 (A3)
unnamed: U101.32 (GPIO27_ADC1), U102.4 (A2)
unnamed: SW102.1, U101.30 (RUN)
unnamed: U102.18 (B1), U105.9, U105.10
unnamed: U102.17 (B2), U105.1, U105.2, U107.9, U107.12
unnamed: U102.16 (B3), U105.4, U105.5, U107.5, U107.13
unnamed: C103.1, J105.2, SW101.3 (C), SW101.6 (C), U104.1 (VI)
unnamed: U105.3, U107.1, U107.4
unnamed: U105.6, U107.2, U107.10
unnamed: U105.8, U105.12, U105.13
unnamed: U106.3 (C), X101.5 (OUT)
unnamed: U106.2 (D), U106.6 (~Q)
unnamed: U106.8 (~Q), U106.12 (D)
unnamed: C205.1, R203.2, R204.2, R205.1, U202.2 (-)
unnamed: C206.2, U203.6 (A)
unnamed: J201.1, J202.R, J202.T, U203.5 (W)
VCC: C104.1, C105.1, C107.1, C108.1, C109.1, C110.1, C201.1, C202.1, J106.3, J106.4, J107.3, J107.4, J108.3, J108.4, J109.3, J109.4, JP101.2 (B), R105.1, U101.40 (VBUS), U102.20 (VCCB), U103.20 (VCCB), U104.3 (VO), U105.14 (VCC), U106.1 (~R), U106.4 (~S), U106.10 (~S), U106.13 (~R), U106.14 (VCC), U107.14 (VCC), U201.8 (V+), U202.8 (V+), X101.8 (Vcc)
/F_A0: J106.10, J107.10, J108.10, J109.10, U102.13 (B6)
/F_A1: J106.12, J107.12, J108.12, J109.12, U102.12 (B7)
/F_CS0: J107.18, U107.3
/F_CS1: J106.18, U107.6
/F_CS2: J109.18, U107.8
/F_CS3: J108.18, U107.11
/F_IC: J106.22, J107.22, J108.22, J109.22, U105.11
/F_IRQ0: J107.20, R106.2, U101.21 (GPIO16)
/F_IRQ1: J106.20, R104.2, U101.22 (GPIO17)
/F_IRQ2: J109.20, R103.2, U101.24 (GPIO18)
/F_IRQ3: J108.20, R102.2, U101.25 (GPIO19)
/F_RD: J106.14, J107.14, J108.14, J109.14, U102.15 (B4)
/F_WR: J106.16, J107.16, J108.16, J109.16, U102.14 (B5)

## KiCad design hardware/OPNA/OPNA.kicad_pcb

Board: 2 copper layers, 80.0 x 50.0 mm, 24 parts (0 on the bottom side), 55 nets.

Parts:
C1, C2, C4, C7: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
C3, C6, C9: 10u; CP_Radial_D6.3mm_P2.50mm
C5: 68p; C_Disc_D4.3mm_W1.9mm_P5.00mm
C8, C10: 2700p; C_Disc_D4.3mm_W1.9mm_P5.00mm
J1: FMB; PinHeader_2x11_P2.54mm_Horizontal
J2: Audio Out; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J3: Audio Out; PinHeader_1x04_P2.54mm_Horizontal
J4: F_GPIO; PinSocket_2x10_P2.54mm_Vertical
J5: GNDA-GND; PinHeader_1x02_P2.54mm_Vertical
R1: 33; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R2: 1K; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R3, R4: 2K; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
REF1, REF2: MountingHole_3.2mm_M3_ISO7380_Pad
U1: NJU7044; DIP-14_W7.62mm_Socket
U2: YM2608B; SDIP64
U3: YM3016; DIP-16_W7.62mm_Socket

Connections:
8MHz: J1.6, U2.63 (PHY-M)
FM1: J2.3, J3.3, R4.1
FM2: J2.2, J3.2, R3.1
F_D0: J1.7, U2.2 (D0)
F_D1: J1.9, U2.3 (D1)
F_D2: J1.11, U2.4 (D2)
F_D3: J1.13, U2.5 (D3)
F_D4: J1.15, U2.6 (D4)
F_D5: J1.17, U2.7 (D5)
F_D6: J1.19, U2.8 (D6)
F_D7: J1.21, U2.9 (D7)
GND: C1.1, J1.1, J1.2, J4.1, J4.2, J5.2, U2.1 (GND), U2.32 (GND), U2.36 (AD), U2.37 (C), U2.38 (DA)
GNDA: C2.2, C3.2, C4.1, C5.2, C7.1, C8.1, C10.1, J2.1, J3.1, J5.1, U1.11 (V-), U2.26 (AGND), U2.39 (AGND), U3.2 (GND)
GPIOA0: J4.5, U2.10 (IOA7)
GPIOA1: J4.7, U2.11 (IOA6)
GPIOA2: J4.9, U2.12 (IOA5)
GPIOA3: J4.11, U2.13 (IOA4)
GPIOA4: J4.13, U2.14 (IOA3)
GPIOA5: J4.15, U2.15 (IOA2)
GPIOA6: J4.17, U2.16 (IOA1)
GPIOA7: J4.19, U2.17 (IOA0)
GPIOB0: J4.6, U2.18 (IOB7)
GPIOB1: J4.8, U2.19 (IOB6)
GPIOB2: J4.10, U2.20 (IOB5)
GPIOB3: J4.12, U2.21 (IOB4)
GPIOB4: J4.14, U2.22 (IOB3)
GPIOB5: J4.16, U2.23 (IOB2)
GPIOB6: J4.18, U2.24 (IOB1)
GPIOB7: J4.20, U2.25 (IOB0)
unnamed: C6.2, R3.2
unnamed: C9.2, R4.2
unnamed: J2.4, J3.4, R2.1
unnamed: C3.1, U1.3 (+), U3.16 (RB)
unnamed: U1.2 (-), U3.15 (BC)
unnamed: C10.2, U1.5 (+), U3.10 (CH1)
unnamed: C9.1, U1.6 (-), U1.7
unnamed: C8.2, U1.10 (+), U3.11 (CH2)
unnamed: C6.1, U1.8, U1.9 (-)
unnamed: C5.1, U1.12 (+), U3.13 (TO_BUFF)
unnamed: R1.1, U1.13 (-), U1.14
unnamed: U2.31 (OP0), U3.4 (SD)
unnamed: U2.64 (PHY-S), U3.5 (CLOCK)
unnamed: U2.29 (SH1), U3.8 (SMP_1)
unnamed: U2.30 (SH2), U3.7 (SMP_2)
unnamed: R1.2, U3.12 (COM)
unnamed: U1.1, U3.14 (MP)
SSG: R2.2, U2.27 (ANALOG_OUT)
VCC: C1.2, C2.1, C4.2, C7.2, J1.3, J1.4, J4.3, J4.4, U1.4 (V+), U2.28 (AVCC), U2.35 (AVCC), U2.62 (VCC), U3.1 (VDD), U3.3 (VDD), U3.6 (FORMSELECT), U3.9 (~ICL)
/F_A0: J1.10, U2.60 (A0)
/F_A1: J1.12, U2.61 (A1)
/F_CS: J1.18, U2.57 (~CS)
/F_IC: J1.22, U2.33 (~IC)
/F_IRQ: J1.20, U2.56 (~IRQ)
/F_RD: J1.14, U2.59 (~RD)
/F_WR: J1.16, U2.58 (~WR)

## KiCad design hardware/OPN/OPN.kicad_pcb

Board: 2 copper layers, 80.0 x 50.0 mm, 19 parts (0 on the bottom side), 48 nets.

Parts:
C1, C2, C3: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
C4, C5: 10u; CP_Radial_D6.3mm_P2.50mm
J1: Audio Out; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical
J2: Audio Out; PinHeader_1x04_P2.54mm_Horizontal
J3: FMB; PinHeader_2x11_P2.54mm_Horizontal
J4: F_GPIO; PinSocket_2x10_P2.54mm_Vertical
J5: GNDA-GND; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R3: 1K; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R4: 2K; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
REF1, REF2: MountingHole_3.2mm_M3_ISO7380_Pad
U1: YM2203C; DIP-40_W15.24mm_Socket
U2: NJM2732; DIP-8_W7.62mm_Socket
U3: YM3014B; DIP-8_W7.62mm_Socket

Connections:
4MHz: J3.8, U1.38 (PHY-M)
FM: J1.3, J2.3, R4.1
F_D0: J3.7, U1.40 (D0)
F_D1: J3.9, U1.2 (D1)
F_D2: J3.11, U1.3 (D2)
F_D3: J3.13, U1.4 (D3)
F_D4: J3.15, U1.5 (D4)
F_D5: J3.17, U1.6 (D5)
F_D6: J3.19, U1.7 (D6)
F_D7: J3.21, U1.8 (D7)
GND: C1.1, J3.1, J3.2, J4.1, J4.2, J5.2, U1.1 (GND)
GNDA: C2.2, C3.1, C4.2, J1.1, J2.1, J5.1, U1.17 (AGND), U2.4 (V-), U3.6 (GND)
GPIOA0: J4.5, U1.16 (IOA0)
GPIOA1: J4.7, U1.15 (IOA1)
GPIOA2: J4.9, U1.14 (IOA2)
GPIOA3: J4.11, U1.13 (IOA3)
GPIOA4: J4.13, U1.12 (IOA4)
GPIOA5: J4.15, U1.11 (IOA5)
GPIOA6: J4.17, U1.10 (IOA6)
GPIOA7: J4.19, U1.9 (IOA7)
GPIOB0: J4.6, U1.26 (IOB0)
GPIOB1: J4.8, U1.27 (IOB1)
GPIOB2: J4.10, U1.28 (IOB2)
GPIOB3: J4.12, U1.29 (IOB3)
GPIOB4: J4.14, U1.30 (IOB4)
GPIOB5: J4.16, U1.31 (IOB5)
GPIOB6: J4.18, U1.32 (IOB6)
GPIOB7: J4.20, U1.33 (IOB7)
unnamed: C5.2, R4.2
unnamed: J1.2, J2.2
unnamed: R1.1, U1.20 (ANALOG-A)
unnamed: R2.1, U1.19 (ANALOG-B)
unnamed: R3.1, U1.18 (ANALOG-C)
unnamed: U1.23 (OP-O), U3.4 (SD)
unnamed: U1.39 (PHY-S), U3.5 (PHI-I)
unnamed: U1.22 (SH), U3.3 (LOAD)
unnamed: C4.1, U2.3 (+), U3.7 (RB)
unnamed: U2.1, U2.2 (-), U3.8 (MP)
unnamed: U2.5 (+), U3.2 (BUFF)
unnamed: C5.1, U2.6 (-), U2.7
SSG: J1.4, J2.4, R1.2, R2.2, R3.2
VCC: C1.2, C2.1, C3.2, J3.3, J3.4, J4.3, J4.4, U1.21 (VCC), U2.8 (V+), U3.1 (VCC)
/F_A0: J3.10, U1.37 (A0)
/F_CS: J3.18, U1.34 (~CS)
/F_IC: J3.22, U1.24 (~IC)
/F_IRQ: J3.20, U1.25 (~IRQ)
/F_RD: J3.14, U1.36 (~RD)
/F_WR: J3.16, U1.35 (~WR)

## Commit log

2025-04-28 Add .vscode/ for pico project
2025-04-28 Support multiple rhythm modules and the group mute
2025-04-29 Init group mute information and update percussion map
2025-05-02 Updated CC#120, 121, and 123 handling to follow General MIDI specification
2025-05-04 chore: minor code cleanup and comments update
2025-06-11 fixed spell mistake
2025-08-23 Fix Issue#4
2025-08-23 Fixed Issue #5
